Commit message: refactor StereoTUM working title -> ShutTUM

File: Examples/ros/src/shuttum/ShutTUM.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link cam1: geometry visual mesh filename=package://shuttum/ShutTUM.dae
